# Autodesk Inventor part: 5MBM21-1-2
## iProperties
Created: 2008-09
Part Number: 5MBM21-1-2
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
